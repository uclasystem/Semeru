## linux-4.11-rc8/drivers/testcase/Kconfig
```kconfig
config TESTCASE
	tristate "Self defined kernel module tset case"
	depends on INFINIBAND
	---help---
	  Self defined external module.
```
